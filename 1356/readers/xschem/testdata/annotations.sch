v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {title.sym} 0 0 0 0 {name=l1 author="Jane Doe"}
C {code_shown.sym} 0 -200 0 0 {name=CMDS value=".op
.tran 1n 10u"}
C {spice_probe.sym} 100 -100 0 0 {name=p1}
C {res.sym} 100 -300 0 0 {name=R1 value=1k}
