v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 100 30 100 90 {}
C {res.sym} 100 0 0 0 {name=R1 value=1k device=resistor}
