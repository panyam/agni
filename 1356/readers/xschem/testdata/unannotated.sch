** sch_path: 1356/readers/xschem/testdata/unannotated.sch
**.subckt unannotated IN
*.ipin IN
R? IN net1 1k m=1
R? net2 net3 2k m=1
R1 net4 net5 4k7 m=1
**.ends
.end
