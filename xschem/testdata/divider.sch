** sch_path: xschem/testdata/divider.sch
**.subckt divider IN OUT
*.ipin IN
*.opin OUT
R1 IN net1 1k m=1
R2 net1 OUT 2k m=1
**.ends
.end
