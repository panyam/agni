v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 100 0 100 30 {lab=SIG}
N 100 -30 100 -60 {lab=VDD}
C {res.sym} 100 0 0 0 {name=R1 value=1k device=resistor}
C {vdd.sym} 100 -60 0 0 {name=l1 lab=VDD}
C {lab_pin.sym} 100 30 0 0 {name=l2 lab=SIG}
