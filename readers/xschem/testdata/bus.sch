v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 100 -60 100 -30 {lab=DATA[7:0]}
