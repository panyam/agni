** sch_path: 1395/readers/xschem/testdata/dup_name.sch
**.subckt dup_name IN OUT
*.ipin IN
*.opin OUT
R1 IN net1 1k m=1
R1 net1 OUT 2k m=1
**.ends
.end
